# Keil uVision project atk_f407.uvprojx, settings and files
target BLDC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\..\USER;..\..\BSP;..\..\BSP\CMSIS\Include;..\..\BSP\CMSIS\Device\ST\STM32F4xx\Include;..\..\BSP\STM32F4xx_HAL_Driver\Inc;..\..\BSP\CMSIS\DSP\Include;..\..\BSP\SYSTEM\sys;..\..\BSP\SYSTEM\delay;..\..\BSP\SYSTEM\usart;..\..\BSP\BLDC_PMSM_CONTROL;..\..\BLDC_PMSM_CONTROL\User\Platform;..\..\BLDC_PMSM_CONTROL\User\GlobalControl;..\..\BLDC_PMSM_CONTROL\User\MotorControl;..\..\UI_and_CONTROL\HMI\LcdControl;..\..\UI_and_CONTROL\HMI\KeyControl;..\..\UI_and_CONTROL\HMI\LedControl;..\..\UI_and_CONTROL\HMI\UsartControl;..\..\UI_and_CONTROL\LCD;..\..\UI_and_CONTROL\TOUCH;..\..\UI_and_CONTROL\IIC;..\..\UI_and_CONTROL\24CXX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../BSP/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../USER/: main.c stm32f4xx_it.c
    ../../BSP/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group BSP/SYSTEM
    ../../BSP/SYSTEM/delay/: delay.c
    ../../BSP/SYSTEM/sys/: sys.c
    ../../BSP/SYSTEM/usart/: usart.c
  group BSP/STM32F4xx_HAL_Driver
    ../../BSP/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c
  group BLDC_PMSM_CONTROL/Platform
    ../../BLDC_PMSM_CONTROL/User/Platform/: f407_bldc_platform.c
  group BLDC_PMSM_CONTROL/GlobalControl
    ../../BLDC_PMSM_CONTROL/User/GlobalControl/: global_control.c
  group BLDC_PMSM_CONTROL/MotorControl
    ../../BLDC_PMSM_CONTROL/User/MotorControl/: motor_system.c motor_identify.c motor_sensorless.c motor_publicdata.c observer_drv.c sample_drv.c eangle_drv.c speed_drv.c math_drv.c foc_drv.c pid_drv.c
  group UI_and_CONTROL/HMI
    ../../UI_and_CONTROL/HMI/LcdControl/: lcd_mid.c lcd_task.c
    ../../UI_and_CONTROL/HMI/KeyControl/: key_drv.c key_task.c
    ../../UI_and_CONTROL/HMI/LedControl/: led_task.c
    ../../UI_and_CONTROL/HMI/UsartControl/: usart_task.c
    ../../UI_and_CONTROL/LCD/: lcd.c
    ../../UI_and_CONTROL/TOUCH/: touch.c ft5206.c gt9xxx.c ctiic.c
    ../../UI_and_CONTROL/IIC/: myiic.c
    ../../UI_and_CONTROL/24CXX/: 24cxx.c
  group CMSIS
    ../../BSP/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
    ../../BSP/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
