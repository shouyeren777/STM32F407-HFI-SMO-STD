/**
  ******************************************************************************
  * 文件名程: 
  * 作    者: 浩盛科技
  * 版    本: V1.0
  * 编写日期: 
  * 功    能: 
  ******************************************************************************
  */
/* 包含头文件 ----------------------------------------------------------------*/

#include "eangle_drv.h"                           

/**
 * 函数功能: 电角度发生器（开环模式）
 * 输入参数: p - 电角度结构体指针，包含设定速度、采样时间等参数
 * 返回参数: 无
 * 说    明: 根据设定的电角速度，通过积分计算生成连续递增（或递减）的电角度，
 *           用于无传感器开环启动或虚拟角度生成。电角度以标幺值（0~1）表示，一周对应1.0。
 */
void Electrical_Angle_Generator(E_ANGLE_STRUCT *p)
{
    // ------------------------------------------------------------------------
    // 1. 电角度积分更新（位置 = 位置 + 速度 × 时间）
    // ------------------------------------------------------------------------
    // p->ElectricalAngleSpdSet : 设定电角速度（单位：转/秒？通常为Hz或rps）
    // p->Ts                   : 控制周期（秒）
    // 0.01666f = 1.0f / 60.0f，此处用于单位转换：
    //   假定 ElectricalAngleSpdSet 单位是 RPM（转/分钟），乘以 Ts 后需除以60转换为转/秒，
    //   再积分得到转数（小数部分即为电角度标幺值）。
    // 最终累加到 ElectricalAngleSetPU（标幺电角度，范围0~1）。
    p->ElectricalAngleSetPU += (p->Ts * p->ElectricalAngleSpdSet * 0.01666f);

    // ------------------------------------------------------------------------
    // 2. 边界处理：将电角度限制在 [0, 1) 范围内（循环累加）
    // ------------------------------------------------------------------------
    // 当电角度超过上限1.0时，减去1.0，相当于角度绕回0点
    if(p->ElectricalAngleSetPU >= 1)
    {
        p->ElectricalAngleSetPU = p->ElectricalAngleSetPU - 1;
    }
    // 当电角度低于0时，加上1.0（通常发生在设定速度为负时）
    if(p->ElectricalAngleSetPU < 0)
    {
        p->ElectricalAngleSetPU = p->ElectricalAngleSetPU + 1;
    }
}


/**
 * 函数功能: 计算外部编码器数据（有感模式）
 * 输入参数: p - 电角度结构体指针，包含编码器原始值、校准偏移、极对数等参数
 * 返回参数: 无
 * 说    明: 根据外部增量式编码器或绝对式编码器的原始计数值，经过方向处理、零点校准、
 *           极对数映射，计算出当前转子的电角度（标幺值，范围0~1）。
 */
void Calculate_Encoder_Data(E_ANGLE_STRUCT *p)
{
    // ------------------------------------------------------------------------
    // 1. 编码器方向处理
    // ------------------------------------------------------------------------
    // 若编码器安装方向与电机定义方向相反，可通过 Dir 标志进行取反修正。
    // p->Dir == 1 表示需要反向，将原始计数值变换为 (最大值 - 原始值) 实现反向计数。
    if(p->Dir == 1)
    {
        p->EncoderVal = p->EncoderValMax - p->EncoderVal;   // 方向取反
    }
    
    // ------------------------------------------------------------------------
    // 2. 计算电角度
    // ------------------------------------------------------------------------
    // 计算步骤：
    //   (1) 原始编码器值减去校准零点偏移（EncoderVal - CalibOffset）
    //   (2) 乘以极对数（PolePairs），将机械角度转换为电角度（每对极对应360°电角度）
    //   (3) 对编码器最大值取模（% p->EncoderValMax），得到在一个编码器周期内的计数值
    s32 ElectricalVal = ((p->EncoderVal - p->CalibOffset) * p->PolePairs) % p->EncoderValMax;
    
    // ------------------------------------------------------------------------
    // 3. 修正可能出现的负值（由于校准偏移或取模运算导致）
    // ------------------------------------------------------------------------
    // 例如，若 (EncoderVal - CalibOffset) 为负，取模结果可能仍为负，导致电角度负值。
    if(ElectricalVal < 0)                                                //处理校准可能带来的负值
    {
        ElectricalVal = ElectricalVal + p->EncoderValMax;                     //计算电角度
    }
    
    // ------------------------------------------------------------------------
    // 4. 计算电角度标幺值
    // ------------------------------------------------------------------------
    p->ElectricalAnglePU = (float)ElectricalVal / (float)p->EncoderValMax;
}




