/**
  ******************************************************************************
  * 文件名程: 
  * 作    者: 浩盛科技
  * 版    本: V1.0
  * 编写日期: 
  * 功    能: 
  ******************************************************************************
  */
/* 包含头文件 ----------------------------------------------------------------*/

#include "pid_drv.h"                                  

/**
 * 函数功能: PID控制（抗积分饱和）
 * 输入参数: p - PID_STRUCT结构体指针，包含比例系数Kp、积分系数Ki、微分系数Kd，
 *          目标值Ref、反馈值Fbk、输出上下限OutMax/OutMin、积分累加Integrate等
 * 返回参数: 无（计算结果存入p->Out）
 * 说    明: 
 *         1. 采用位置式PID算法，计算公式：
 *            Out = Kp * Err + Integral + Kd * (Err - ErrLast)
 *         2. 抗积分饱和策略：
 *            只有当输出未达到限幅值（OutMin < Out < OutMax）时，才累加积分项。
 *            如果输出已经饱和，则停止积分累加，防止积分过深导致退出饱和时响应滞后。
 *         3. 误差计算：Err = Ref - Fbk（可适应正反向调节）
 *         4. 微分项使用当前误差与上次误差之差，实现不完全微分（未滤波）。
 *         5. 输出限幅：最终Out被限制在[OutMin, OutMax]范围内，确保控制量不超限。
 *         6. 该PID适用于电机控制中的电流环、速度环、位置环等。
 */
void PID_Control(PID_STRUCT *p)
{
    p->Err = p->Ref - p->Fbk;                           // 计算当前误差

    // 抗积分饱和：只有输出未饱和时才累加积分项
    if (p->Out < p->OutMax && p->Out > p->OutMin)
    {
        p->Integrate = p->Integrate + p->Ki * p->Err;   // 积分累加（Ki已包含采样时间）
    }

    // 计算PID输出（比例+积分+微分）
    p->Out = p->Kp * p->Err +                           // 比例项
             p->Integrate +                             // 积分项
             p->Kd * (p->Err - p->ErrLast);             // 微分项

    // 输出上限幅
    if (p->Out >= p->OutMax)
    {
        p->Out = p->OutMax;
    }
    // 输出下限幅
    if (p->Out <= p->OutMin)
    {
        p->Out = p->OutMin;
    }

    p->ErrLast = p->Err;                                // 保存本次误差供下次微分使用
}

/**
 * 函数功能: 重置PID所有相关变量为零
 * 输入参数: p - PID_STRUCT结构体指针
 * 返回参数: 无
 * 说    明: 
 *         将PID控制器的目标值、反馈值、输出值、误差值、上次误差、积分项全部清零。
 *         通常在电机启动前、模式切换时或参数重新整定前调用，避免历史数据干扰新的控制过程。
 *         注意：该函数不改变PID的Kp、Ki、Kd、输出限幅等配置参数，仅重置运行状态变量。
 */
void PID_Clear(PID_STRUCT *p)
{
    p->Ref = 0;       // 重置目标值
    p->Fbk = 0;       // 重置反馈值
    p->Out = 0;       // 重置输出值
    p->Err = 0;       // 重置误差值
    p->ErrLast = 0;   // 重置上次误差值
    p->Integrate = 0; // 重置积分累加项
}



